r1 a b 1k
.end
r2 b c 2k
